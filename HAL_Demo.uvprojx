# Keil uVision project HAL_Demo.uvprojx, settings and files
target HAL_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103V8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HAL_Demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: .\HAL_LIB\core;.\HAL_LIB\core\Include;.\HAL_LIB\Include;.\HAL_LIB\STM32F1xx_HAL_Driver\Inc;.\HAL_LIB\STM32F1xx_HAL_Driver\Inc\Legacy;.\User;.\Sys;.\App;.\Custom;.\NB_LIB\inc
  memory RVCT4: ROM 0x8000400 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Stratup
    ./User/: startup_stm32f103xb.s
  group Custom
    ./Custom/: base.h
  group HAL_LIB
    ./HAL_LIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group NB_LIB
    ./NB_LIB/src/: CRC.C Fifo.c
    ./NB_LIB/inc/: CRC.h Fifo.h
  group Sys
    ./Sys/: gpio.c gpio.h Sys.c Sys.h usart1.c usart1.h
  group User
    ./User/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c stm32f1xx_hal_conf.h stm32f1xx_it.h
    ./HAL_LIB/Include/: stm32f1xx.h
  group App
    ./App/: flash.c flash.h 485_function.c 485_function.h Command_Parse.c Command_Parse.h update.c update.h
  group ReadMe
    ./: ReadMe.txt
